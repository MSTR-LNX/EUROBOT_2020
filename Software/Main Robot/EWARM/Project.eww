<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\BLACK_R.ewp</path>
  </project>
  <batchBuild />
</workspace>
